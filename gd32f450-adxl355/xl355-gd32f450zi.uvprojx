# Keil uVision project xl355-gd32f450zi.uvprojx, settings and files
target adxl355 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F450ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xl355-gd32f450zi
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F450,GD32F4
  c include: .\CMSIS;.\CMSIS\GD\GD32F4xx\Include;.\GD32F4xx_standard_peripheral\Include;.\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./source/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ./CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Driver
    ./GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
