# Keil uVision project stm32h743_learn.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32h743_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: .\CMSIS;.\DRIVER;.\HALLIB\Inc;.\USER;.\USER\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x2000000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743_template.sct
  group CMSIS
    ./CMSIS/: startup_stm32h743xx.s
  group STM32H7xx_HAL_Driver
    ./HALLIB/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_sdram.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_usart.c stm32h7xx_ll_rcc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dma.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_usart.c
  group USER
    ./USER/: main.c stm32h7xx_it.c system_stm32h7xx.c
  group DRIVER
    ./DRIVER/: led.c usart.c key.c sdram.c
