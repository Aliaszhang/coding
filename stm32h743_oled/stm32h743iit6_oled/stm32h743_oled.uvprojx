# Keil uVision project stm32h743_oled.uvprojx, settings and files
target oled (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32h743_oled +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=7 wLevel=2
  c define: STM32H743xx
  c include: .\user\HARDWARE;.\user\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group startup
    ./: startup_stm32h743xx.s
  group hardware
    ./user/HARDWARE/: exti.c key.c led.c oled.c timer.c tpad.c wdg.c spi.c
  group system
    ./user/SYSTEM/: delay.c sys.c usart.c
  group user
    ./: main.c
